FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://task2g-verified-boot.cfg"
